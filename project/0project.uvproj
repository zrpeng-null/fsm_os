# Keil uVision project 0project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 0project +hex
  AfterMake: fromelf.exe --bin obj/0project.axf --output 0project.bin
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\source\FWLIB\inc;..\source\system;..\source\user;..\source\hal;..\source\FWLIB\CMSIS;..\source\fsm_os;..\source\system\fcmd
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../source/user/: app_task.c main.c
  group SYSTEM
    ../source/system/: delay.c sys.c usart.c xprintf.c
    ../source/system/fcmd/: cmd_mem.c fcmd.c fcmd_cfg.h
  group FWLIB
    ../source/FWLIB/: STM32FWLIB_V35.lib
    ../source/FWLIB/startup/: startup_stm32f10x_hd.s
    ../source/FWLIB/CMSIS/: core_cm3.c core_cm3.h system_stm32f10x.c
  group hal
    ../source/hal/: hal_driver.c led.c
  group fsm_os
    ../source/fsm_os/: os.c cpu.asm
